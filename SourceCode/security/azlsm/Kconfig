## SourceCode/security/azlsm/Kconfig
```kconfig
config     SECURITY_AZLSM
   bool     "azlsm support"
   depends on SECURITY
   default     n
   help
        introduction of azlsm
```
